## boards/samk75/Kconfig.samk75
```kconfig
config BOARD_SAMK75
    select SOC_NRF52840_QIAA
    imply RETAINED_MEM
    imply RETENTION
    imply RETENTION_BOOT_MODE
```
